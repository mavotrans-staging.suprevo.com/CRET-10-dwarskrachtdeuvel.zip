Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-06T08:18:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 06 08:18:28 2023 * Host: MAV-DTP-TESSA * Database: C:\Users\T6FAF~1.PLA\AppData\Local\Temp\fdaae377-05c3-4360-8a65-4f585b0c56b6\2f23888d-69f6-4edf-8b70-f5199a1fd7ba\ifc * Database version: 5507 * Database creation date: Thu Apr 06 08:18:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 06 08:18:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 06 08:18:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: CRET-10/20-350, NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20:CRET-10/20-350:340407
In: Level 0
Type - Description: Dwarskrachtdeuvel | Shear load connector; Material: Corrossiebestendigheidsklasse 2, Corrosion resistance class 2
Type - Constraints - Default Elevation: 200 mm
Type - Dimensions - Diameter Ø: 20 mm; Dowel length: 350 mm
Type - Identity Data - Artikelnummer | Article number: CRET-10/20-350; Beschrijving | Description: Dwarskrachtdeuvel | Shear load connector; Laatste versie | Last version: 31-03-2023; Leverancier | Supplier: Mavotrans; NL-SfB code: 28; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: CRET-10/20-350; URL: https://mavotrans.nl/producten/betonkoppelsystemen/dwarskrachtdeuvels.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Dowel_material: Corrossiebestendigheidsklasse 2, Corrosion resistance class 2
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20
Type - Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20:CRET-10/20-350
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20:CRET-10/20-350
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Schedule Level: Level: Level 0
Construction - bm_distance: 30 mm; d_position: 170 mm
Dimensions - Area: 0.387132 m2; e_accepted: 20 mm; e Fuge / joint / guinto: 20 mm; Einbindelaenge: 180 mm; Huelsenlaenge / Longeur de la gaine: 170 mm; Huelsenlaenge_accepted: 170 mm; Volume: 0.000109951 m3
Graphics - CRET_J: no; CRET_P: no; CRET_V20: no; sleeve_vis: no; sleeve warning: no; warning: no
Identity Data - Lateral displacement +/-: 0 mm
Other - Family: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20: CRET-10/20-350; Family and Type: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20: CRET-10/20-350; J_170: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101417_CRET-J/20-170; J_195: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101419_CRET-J/20-195; J_220: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101422_CRET-J/20-220; J_270: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101427_CRET-J/20-270; J_320: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101432_CRET-J/20-320; P_170: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170; P_195: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101619_CRET-P/20-195; P_220: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101622_CRET-P/20-220; P_270: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101627_CRET-P/20-270; P_320: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170; Sleeve: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101532_CRET-V20/20-320; Type: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20: CRET-10/20-350; Type Id: NLRSnl_28_GM_WPB_101-CRET-10-13_-P-J-V20_R20: CRET-10/20-350; V20_170: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101517_CRET-V20/20-170; V20_195: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101519_CRET-V20/20-195; V20_220: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101522_CRET-V20/20-220; V20_270: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101527_CRET-V20/20-270; V20_320: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101532_CRET-V20/20-320
Phasing - Phase Created: New Construction
